# Keil uVision project project.uvprojx, settings and files
target DAPLink-Wireless (6240000::V6.24::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x03F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: daplink_wireless
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD,HXTAL_VALUE=8000000U,USBD_EP0_MAX_SIZE=32U
  c include: .\app;.\bsp;.\drivers\radio;.\drivers\serial;.\drivers\swd;.\usb;..\vendor\GD32F30x_usbd_library\device\Include;..\vendor\GD32F30x_usbd_library\usbd\Include;..\vendor\GD32F30x_usbd_library\class\device\msc\Include;..\vendor\GD32F30x_usbd_library\class\device\cdc\Include;..\vendor\GD32_CMSIS;..\vendor\GD32_CMSIS\GD\GD32F30x\Include;..\vendor\GD32F30x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --map --list=..\build\keil\listings\daplink_wireless.map
  group Application
    ./app/: main.c cmsis_dap.c frequency_hopping.c link_adaptation.c radio_protocol.c radio_window.c serial_service.c serial_bridge.c status_indicator.c swd_bridge_service.c swd_tunnel.c device_config.c device_config_storage.c
  group USB Composite Device
    ./usb/: usb_config_disk.c usb_composite.c usb_vendor_request.c usb_standard_request.c cdc_acm_transport.c cmsis_dap_usb.c
  group GD32 USBD Middleware
    ../vendor/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
    ../vendor/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
    ../vendor/GD32F30x_usbd_library/class/device/msc/Source/: usbd_msc_core.c usbd_msc_bbb.c usbd_msc_scsi.c
  group Board Support
    ./bsp/: board.c
  group Radio
    ./drivers/radio/: radio_hal.c sx128x.c
  group Serial
    ./drivers/serial/: target_uart.c target_uart_ring.c
  group SWD
    ./drivers/swd/: target_swd.c
  group GD32 Standard Peripheral
    ../vendor/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_misc.c gd32f30x_usart.c gd32f30x_dma.c
  group Device
    ../vendor/GD32_CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../vendor/GD32_CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
